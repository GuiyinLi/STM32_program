# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\CORE;..\STM3210X\inc;..\SYSTEM\usart;..\FWLIB\KEY;..\SYSTEM\usart;..\FWLIB\LED;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TASK;..\TASK\LED_TASK;..\FreeRTOS\include;..\TASK\LIST_TASK;..\FWLIB\KEY;..\TASK\QUEUE_TASK;..\FWLIB\TIMER;..\TASK\API;..\TASK\QUEUE_TASK;..\TASK\SEMAPHORE;..\TASK\TIMER_TASK;..\TASK\EVENT_TASK;..\TASK\HEAP_TASK;..\TASK\TASKNOTIFY_TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM3210X
    ../STM3210X/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group FWLIB
    ../FWLIB/KEY/: key.c
    ../FWLIB/LED/: led.c
    ../FWLIB/TIMER/: timer.c
  group TASK
    ../TASK/LED_TASK/: led_task.c
    ../TASK/: task.c
    ../TASK/LIST_TASK/: list_task.c
    ../TASK/QUEUE_TASK/: queue_task.c
    ../TASK/API/: api.c
    ../TASK/SEMAPHORE/: semaphore.c
    ../TASK/TIMER_TASK/: timer_task.c
    ../TASK/EVENT_TASK/: event_task.c
    ../TASK/HEAP_TASK/: heap_task.c
    ../TASK/TASKNOTIFY_TASK/: tasknotify_task.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
