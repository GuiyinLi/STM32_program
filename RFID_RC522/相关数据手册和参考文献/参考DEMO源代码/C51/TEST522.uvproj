# Keil uVision project TEST522.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: P89LPC922 Philips
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000) MODP2
  output: TEST522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: MAIN.C RC522.C
